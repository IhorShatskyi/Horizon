# Keil uVision project Horizon.uvprojx, settings and files
target Horizon+ (6140000::V6.14::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Horizon +hex
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 wLevel=2
  c misc: -Wno-missing-variable-declarations
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group common
    ./: main.c define.h welcome.h
  group init
    ./: init.h init.c
  group delay
    ./: delay.h delay.c
  group wiznet
    ./: w5500.h wiznet.h wiznet.c
  group spi
    ./: spi.h spi.c
  group flash
    ./: flash.h flash.c
  group list
    ./: list.h list.c
  group iq
    ./: iq.h iq.c
  group print
    ./: print.h print.c
  group dmaTransfer
    ./: dmaTransfer.h dmaTransfer.c
  group button
    ./: button.h button.c
  group led
    ./: led.h led.c
  group statusConnect
    ./: statusConnect.h statusConnect.c
  group horizon
    ./: horizonParser.h horizonParser.c horizonDriver.h horizonDriver.c horizonCore.h horizonCore.c horizon.h horizon.c
  group socket
    ./: socket.h socket.c
  group irq
    ./: irq.h irq.c
  group digitalUpConverter
    ./: ducDriver.h ducDriver.c ducParser.h ducParser.c
  group digitalDownConverter
    ./: ddcDriver.h ddcDriver.c ddcParser.h ddcParser.c
  group device
    ./: device.h device.c
  group statusBar
    ./: statusBar.h statusBar.c
  group Storona
    ./: storonaParser.h storonaParser.c storona.h storona.c storonaDriver.h storonaDriver.c storonaCore.h storonaCore.c
  group QFSK
    ./: modulatorQFSK.h modulatorQFSK.c demodulatorQFSK.h demodulatorQFSK.c
  group SemplSender
    ./: semplSender.h semplSender.c
  group BitBuffer
    ./: bitBuffer.h bitBuffer.c
  group debugSempl
    ./: debugSempl.h debugSempl.c
  group vco
    ./: vco.h vco.c
  group timeErrorDetect
    ./: timeErrorDetect.h timeErrorDetect.c
  group loopFilter
    ./: loopFilter.h loopFilter.c
  group agc
    ./: agc.h agc.c
software components: CMSIS:CORE 5.3.0, Device:Startup 2.6.3
